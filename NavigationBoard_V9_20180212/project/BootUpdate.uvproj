# Keil uVision project BootUpdate.uvproj, settings and files
target laser and cord (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BootUpdate +hex
  AfterMake: fromelf.exe --bin -o ./BootUpdateApp.bin ./output/BootUpdate.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F1XX,STM32F10X_MD
  c include: ..\source\API;..\source\APP;..\source\Driver;..\source\user;..\Libraries\CMSIS\Include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\MyLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group API
    ../source/API/: CRC.c EncoderNavigation.c
  group USR
    ../source/user/: main.c stm32f10x_it.c system_stm32f10x.c
  group Driver
    ../source/Driver/: clock.c iap.c CAN.c IO.c usart.c UART3.c Timer.c Lib_Encoder.c
  group APP
    ../source/APP/: encoder.c NAV350.c key.c lift.c motor.c
  group LIB
    ../MyLib/: CAN_stm32f1xx.lib usart_stm32f1xx.lib retarget_printf_stm32f1xx.lib FIFO_M3.lib IO_stm32f1xx.lib
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_tim.c
